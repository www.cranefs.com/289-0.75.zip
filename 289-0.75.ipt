# Autodesk Inventor part: 289-0.75
## iProperties
Created: 2007-07
Part Number: 289-0.75
Document SubType Name: Modeling
Designer: btaylor
Density: 1 g/cm^3
Author: btaylor
